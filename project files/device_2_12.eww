<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\v.12.x.y\device_2_v_12_0_1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


